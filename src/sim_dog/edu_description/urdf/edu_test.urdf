Commit message: 增加导航相关功能包

File: src/sim_dog/edu_description/urdf/edu_test.urdf (robot description, URDF)
Before this commit: robot edu_urdf, 20 links, 19 joints
Links:
- removed link laser_up
Joints:
- removed joint laser_up_joint
